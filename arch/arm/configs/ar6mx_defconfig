## drivers/net/wireless/realtek/rtl88x2be/Kconfig
```kconfig
config RTL8822BE
	tristate "Realtek 8822B PCIE WiFi"
	depends on PCIEPORTBUS
	---help---
	  Help message of RTL8822BE
```
